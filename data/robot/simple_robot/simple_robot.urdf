Commit message: update code

File: data/robot/simple_robot/simple_robot.urdf (robot description, URDF)
Before this commit: robot simple_robot, 3 links, 2 joints
Joints:
- joint joint2: origin (none) -> xyz=0.5 0 0
